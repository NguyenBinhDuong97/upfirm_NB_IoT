# IAR project Host.ewp, settings and files
configuration Host (ARM, debug)
  General.OGChipSelectEditMenu: STM32L082KZ ST STM32L082KZ
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L082xx
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32L0xx_HAL_Driver/Inc; ../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM0; ../Drivers/CMSIS/Device/ST/STM32L0xx/Include; ../Drivers/CMSIS/Include; D:\Source_Tree_data\projects\NB_IoT\Update_OTA\upfirm_NB_IoT\Updata_OTA_NBIoT\MCU\HostClientEWARM\HostVer2\BC66\Inc; D:\Source_Tree_data\projects\NB_IoT\Update_OTA\upfirm_NB_IoT\Updata_OTA_NBIoT\MCU\HostClientEWARM\HostVer2\connect; D:\Source_Tree_data\projects\NB_IoT\Update_OTA\upfirm_NB_IoT\Updata_OTA_NBIoT\MCU\HostClientEWARM\HostVer2\LibMQTT\inc; D:\Source_Tree_data\projects\NB_IoT\Update_OTA\upfirm_NB_IoT\Updata_OTA_NBIoT\MCU\HostClientEWARM\HostVer2\own_lib\inc; D:\Source_Tree_data\projects\NB_IoT\Update_OTA\upfirm_NB_IoT\Updata_OTA_NBIoT\MCU\HostClientEWARM\HostVer2\uartWinApp
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Core\Inc
  OBJCOPY.OOCOutputFile: Host.hex
  ILINK.IlinkOutputFile: Host.out
  ILINK.IlinkIcfFile: stm32l082xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l082xx.s
  group Application/User/Core
    ../Core/Src/: freertos.c gpio.c main.c rtc.c stm32l0xx_hal_msp.c stm32l0xx_hal_timebase_tim.c stm32l0xx_it.c usart.c
  group BC66/inc
    ../BC66/Inc/: bc66_cmd.h bc66_uart.h call_back_fnc.h pin_config.h
  group BC66/src
    ../BC66/Src/: bc66_cmd.c bc66_uart.c call_back_fnc.c
  group connect/inc
    ../connect/: MQTT.h TCP_IP.h
  group connect/src
    ../connect/: MQTT.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_exti.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c
  group LibMQTT/inc
    ../LibMQTT/inc/: MQTTConnect.h MQTTFormat.h MQTTPacket.h MQTTPublish.h MQTTSubscribe.h MQTTUnsubscribe.h StackTrace.h
  group LibMQTT/src
    ../LibMQTT/source/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM0/: port.c portasm.s
  group ownLib/inc
    ../own_lib/inc/: my_lib.h my_rtc.h my_uart.h
  group ownLib/src
    ../own_lib/src/: my_lib.c my_rtc.c my_uart.c
  group uartWinApp/inc
    ../uartWinApp/: uartWinnApp.h
  group uartWinApp/src
    ../uartWinApp/: uartWinApp.c
